# IAR project raw_freertos_stm32f103c8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS; FreeRTOS; FreeRTOS\include; FreeRTOS\src; FreeRTOS\port; CMSIS\include; CMSIS\src; task specific\include; stm32uart\include; stm32uart\; stm32adc\; stm32adc\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: raw_freertos_stm32f103c8.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\1\Documents\Irkutsk Task\raw_freertos_stm32f103c8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group CMSIS/include
    CMSIS/include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm3.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/src
    CMSIS/src/: startup_stm32f103xb.s system_stm32f1xx.c
  group FreeRTOS
    FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/include
    FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    FreeRTOS/port/: port.c portasm.s portmacro.h
  group FreeRTOS/src
    FreeRTOS/src/: heap_4.c list.c queue.c tasks.c timers.c
  group stm32adc
    stm32adc/: stm32adcConfig.h
  group stm32adc/include
    stm32adc/include/: stm32adc.h stm32adc_manager.h
  group stm32adc/port
    stm32adc/port/: stm32adc_port.cpp
  group stm32adc/src
    stm32adc/src/: stm32adc.cpp stm32adc_manager.cpp
  group stm32uart
    stm32uart/: stm32uartConfig.h
  group stm32uart/include
    stm32uart/include/: stm32uart.h stm32uart_buffer.h stm32uart_manager.h stm32uart_messages.h
  group stm32uart/port
    stm32uart/port/: stm32uart_port.cpp
  group stm32uart/src
    stm32uart/src/: stm32uart.cpp stm32uart_buffer.cpp stm32uart_manager.cpp stm32uart_messages.cpp
  group task specific/include
    task specific/include/: led_blinker.h parser.h voltmeter.h voltmeter_channel.h
  group task specific/src
    task specific/src/: led_blinker.cpp voltmeter.cpp voltmeter_channel.cpp
